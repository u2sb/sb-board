# Repository u2sb/sb-board

## KiCad design Hardware/sbs3-board/sbs3-board.kicad_pcb

Parts:
BT1, BT2: BT-503450
C1, C7, C10, C14, C17: 10uF; C_0805_2012Metric
C2, C3, C5, C8, C9, C11, C12, C13, C18: 100nF; C_0805_2012Metric
C4, C6: 22uF; C_0805_2012Metric
C15: 100uF; CP_Elec_6.3x5.4
C16, C19: 1uF; C_0805_2012Metric
D1, D2, D3, D4: D1FH3; D_SMA
D5: LED_R; LED_0603_1608Metric
D6: LED_B; LED_0603_1608Metric
J1, J2, J3, J4: Conn_01x20_Male; PinHeader_1x20_P2.54mm_Vertical
J5, J6: Conn_02x03_Odd_Even; PinHeader_2x03_P2.54mm_Vertical
L1, L2: 10uH; L_Abracon_ASPI-0630LR
Q1: PW2320; SOT-23
Q2: PW8205A8; TSSOP-8_4.4x3mm_P0.65mm
Q3, Q4: SS8050; SOT-23
R1: 0.12R; R_2512_6332Metric
R2, R9: 330R; R_0805_2012Metric
R3, R4, R5, R6, R15: 5.1K; R_0805_2012Metric
R7: 5R; R_0805_2012Metric
R8: 20R; R_0805_2012Metric
R10: 1K; R_0805_2012Metric
R11, R12, R14, R18, R19: 10K; R_0805_2012Metric
R13, R17: 100K; R_0805_2012Metric
R16: 22K; R_0805_2012Metric
R20, R21: 750; R_0805_2012Metric
SW1: SW_Push_DPDT; SW_E-Switch_EG1271_DPDT
SW2, SW3: SW_Push; SW_SPST_CK_RS282G05A3
U1: PW7152; SOT-23-6
U2: PW4202; SOIC-8_3.9x4.9mm_P1.27mm
U3: CH340C; SOIC-16_3.9x9.9mm_P1.27mm
U4: SY8286ARAC; QFN-20-1EP_3x3mm_P0.45mm_EP1.6x1.6mm_ThermalVias
U5: OLED_096_IIC
U6: ESP32-S3-WROOM-1
USB1, USB2: USB_C_Receptacle_USB2.0; USB_C_Receptacle_Palconn_UTC16-G

Connections:
+3V3: C1.2, C2.2, C13.1, C14.1, C15.1, C17.1, C18.1, J1.2, J2.2, J5.1, J5.3, J5.5, J6.1, J6.3, J6.5, L2.2, R13.1, R18.1, R19.1, R20.1, U3.4 (V3), U3.16 (VCC), U5.2 (VCC), U6.2 (3V3)
+5V: C10.1, C11.1, D1.1 (K), D2.1 (K), D4.1 (K), R14.1, U4.2 (IN), U4.3 (IN), U4.4 (IN), U4.5 (IN)
/BAT: BT1.1 (+), C6.2, C8.2, D3.1 (K), D4.2 (A), R2.2, U2.3 (BAT)
/BGND: C4.1, C5.2, C6.1, C7.1, C8.1, Q1.2 (S), Q2.6 (S2), Q2.7 (S2), R10.2, SW1.3 (C), SW1.6 (C), U2.4 (GND)
/BT-: BT2.2 (-), C3.1, C9.1, Q2.2 (S1), Q2.3 (S1), U1.6 (VSS)
/ESP_EN: C19.2, J1.3, J2.3, Q3.3 (C), R18.2, SW2.2, U6.3 (EN)
/ESP_IO0: J3.14, J4.14, Q4.3 (C), R19.2, SW3.2, U6.27 (IO0)
/ESP_IO2: J3.3, J4.3, R21.1, U6.38 (IO2)
/ESP_RX: J3.5, J4.5, U3.2 (TXD), U6.36 (RXD0)
/ESP_SCL: J1.17, J2.17, U5.3 (SCL), U6.17 (IO9)
/ESP_SDA: J1.12, J2.12, U5.4 (SDA), U6.12 (IO8)
/ESP_TX: J3.4, J4.4, U3.3 (RXD), U6.37 (TXD0)
/ESP_USB+: J1.14, J2.14, U6.14 (IO20), USB2.A6 (D+), USB2.B6 (D+)
/ESP_USB-: J1.13, J2.13, U6.13 (IO19), USB2.A7 (D-), USB2.B7 (D-)
/LX1: L1.1, R1.1, U2.8 (CSN)
/LX2: C12.2, L2.1, U4.6 (LX), U4.19 (LX), U4.20 (LX)
/USB0+: U3.5 (UD+), USB1.A6 (D+), USB1.B6 (D+)
/USB0-: U3.6 (UD-), USB1.A7 (D-), USB1.B7 (D-)
/VIN1: D1.2 (A), USB1.A4 (VBUS), USB1.A9 (VBUS), USB1.B4 (VBUS), USB1.B9 (VBUS)
/VIN2: C4.2, C5.1, D2.2 (A), R1.2, R7.2, U2.2 (CE), U2.7 (VIN), USB2.A4 (VBUS), USB2.A9 (VBUS), USB2.B4 (VBUS), USB2.B9 (VBUS)
GND: C1.1, C2.1, C10.2, C11.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.1, D5.1 (K), D6.1 (K), J1.1, J2.1, J3.1, J4.1, J5.2, J5.4, J5.6, J6.2, J6.4, J6.6, R3.2, R4.2, R5.2, R6.2, R15.1, R16.2, R17.1, SW1.2 (B), SW1.5 (B), SW2.1, SW3.1, U3.1 (GND), U4.7 (GND), U4.8 (GND), U4.18 (GND), U4.21 (GND), U5.1 (GND), U6.1 (GND), U6.40 (GND), U6.41 (GND), USB1.A1 (GND), USB1.A12 (GND), USB1.B1 (GND), USB1.B12 (GND), USB1.S1 (SHIELD), USB2.A1 (GND), USB2.A12 (GND), USB2.B1 (GND), USB2.B12 (GND), USB2.S1 (SHIELD)
unnamed: BT1.2 (-), BT2.1 (+), R9.2
unnamed: C3.2, R2.1, U1.5 (VDD)
unnamed: C7.2, R7.1
unnamed: C9.2, R9.1, U1.4 (VC)
unnamed: C12.1, U4.1 (BS)
unnamed: C16.1, U4.17 (VCC)
unnamed: D3.2 (A), L1.2, Q1.3 (D)
unnamed: D5.2 (A), R20.2
unnamed: D6.2 (A), R21.2
unnamed: J1.4, J2.4, U6.4 (IO4)
unnamed: J1.5, J2.5, U6.5 (IO5)
unnamed: J1.6, J2.6, U6.6 (IO6)
unnamed: J1.7, J2.7, U6.7 (IO7)
unnamed: J1.8, J2.8, U6.8 (IO15)
unnamed: J1.9, J2.9, U6.9 (IO16)
unnamed: J1.10, J2.10, U6.10 (IO17)
unnamed: J1.11, J2.11, U6.11 (IO18)
unnamed: J1.15, J2.15, U6.15 (IO3)
unnamed: J1.16, J2.16, U6.16 (IO46)
unnamed: J1.18, J2.18, U6.18 (IO10)
unnamed: J1.19, J2.19, U6.19 (IO11)
unnamed: J1.20, J2.20, U6.20 (IO12)
unnamed: J3.2, J4.2, U6.39 (IO1)
unnamed: J3.6, J4.6, U6.35 (IO42)
unnamed: J3.7, J4.7, U6.34 (IO41)
unnamed: J3.8, J4.8, U6.33 (IO40)
unnamed: J3.9, J4.9, U6.32 (IO39)
unnamed: J3.10, J4.10, U6.31 (IO38)
unnamed: J3.11, J4.11, U6.30 (IO37)
unnamed: J3.12, J4.12, U6.29 (IO36)
unnamed: J3.13, J4.13, U6.28 (IO35)
unnamed: J3.15, J4.15, U6.26 (IO45)
unnamed: J3.16, J4.16, U6.25 (IO48)
unnamed: J3.17, J4.17, U6.24 (IO47)
unnamed: J3.18, J4.18, U6.23 (IO21)
unnamed: J3.19, J4.19, U6.22 (IO14)
unnamed: J3.20, J4.20, U6.21 (IO13)
unnamed: Q1.1 (G), R8.1
unnamed: Q2.1 (D1/D2), Q2.8 (D1/D2)
unnamed: Q2.4 (G1), U1.1 (DOUT)
unnamed: Q2.5 (G2), U1.2 (COUT)
unnamed: Q3.1 (B), R11.1
unnamed: Q3.2 (E), R12.2, U3.14 (~RTS)
unnamed: Q4.1 (B), R12.1
unnamed: Q4.2 (E), R11.2, U3.13 (~DTR)
unnamed: R3.1, USB1.A5 (CC1)
unnamed: R4.1, USB2.A5 (CC1)
unnamed: R5.1, USB1.B5 (CC2)
unnamed: R6.1, USB2.B5 (CC2)
unnamed: R8.2, U2.5 (LDRV)
unnamed: R10.1, U1.3 (VM)
unnamed: R13.2, R16.1, U4.14 (FB)
unnamed: R14.2, U4.11 (EN)
unnamed: R15.2, U4.13 (ILMT)
unnamed: R17.2, U4.12 (MODE)

Notes on the sheet:
3.3V降压电路
电池和保护电路
充电电路连接在一起再接系统地 充电电路接地时与4脚分开接地
USB转串口
充电电路
USB
供电切换电路

Board: 2 copper layers, 100.0 x 60.0 mm, 71 parts (2 on the bottom side), 76 nets.

## KiCad design Hardware/sbs2-board/sbs2-board.kicad_pcb

File Hardware/sbs2-board/readme.md:

# ESP32S2开发板

## 缺陷

打板验证，目前USB拓展不可用，其他功能正常，因为要做S3开发板，这个项目就不打算修复了，电路仅作参考。

Parts:
BT1, BT2: BT-503450
C101, C102, C313: 100uF; CP_Elec_6.3x5.4
C104, C201, C303, C306, C307, C309, C310, C311, C401: 100nF; C_0805_2012Metric
C105, C202, C301, C402: 10uF; C_0805_2012Metric
C302, C304, C305, C308, C312: 22uF; C_0805_2012Metric
C314: 22pF; C_0805_2012Metric
C403: 1uF; C_0805_2012Metric
D301, D302, D303: D1FH3; D_SMA
D401: LED_R; LED_0603_1608Metric
D402: LED_B; LED_0603_1608Metric
F101: 6V 1A; Fuse_1206_3216Metric
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3_ISO14580
J401, J402: Conn_01x14_Male; PinHeader_1x14_P2.54mm_Vertical
J403: Conn_01x07_Male; PinHeader_1x07_P2.54mm_Vertical
J404: Conn_01x06_Male; PinHeader_1x06_P2.54mm_Vertical
J406, J407: Conn_02x03_Odd_Even; PinHeader_2x03_P2.54mm_Vertical
L301: 10uH; L_Abracon_ASPI-0630LR
L302: 4.7uH; L_Abracon_ASPI-0630LR
Q201, Q202: SS8050; SOT-23
Q301, Q303: PW2320; SOT-23
Q302: PW8205A8; TSSOP-8_4.4x3mm_P0.65mm
R101: 5.1K; R_0805_2012Metric
R102, R307: 100K; R_0805_2012Metric
R201, R202, R310, R401, R402: 10K; R_0805_2012Metric
R301: 5R; R_0805_2012Metric
R302: 0.12R; R_2512_6332Metric
R303: 20R; R_0805_2012Metric
R304, R305: 330R; R_0805_2012Metric
R306: 1K; R_0805_2012Metric
R308: 47K; R_0805_2012Metric
R309: 15K; R_0805_2012Metric
R403, R404: 750; R_0805_2012Metric
SW301: SW_Push_DPDT; SW_E-Switch_EG1271_DPDT
SW401, SW402: SW_Push; SW_SPST_CK_RS282G05A3
U101: HS8836A; SOIC-16_3.9x9.9mm_P1.27mm
U201: CH340C; SOIC-16_3.9x9.9mm_P1.27mm
U301: PW4202; SOIC-8_3.9x4.9mm_P1.27mm
U302: PW7152; SOT-23-6
U303: PW2312; SOT-23-6
U401: ESP32-S2-WROVER; ESP32-S2-WROVER-I
U402: OLED_096_IIC
USB101: USB3_B; USB3.0_TYPE-B
USB102: USB_C_Receptacle; TYPE-C-SMD_TYPE-C-24P-QCHT
USB103: USB3_A; USB3.0-A-TH_FUS301-FDBU1K
USB104: USB_A; USB-AF-10.0-023

Connections:
+3V3: C201.2, C202.2, C311.2, C312.2, C313.1, C314.2, C401.1, C402.1, J404.1, J406.1, J406.3, J406.5, J407.1, J407.3, J407.5, L302.2, R308.2, R401.1, R402.1, R403.1, U201.4 (V3), U201.16 (VCC), U401.2 (3V3), U402.2
+5V: C101.1, C102.1, C302.2, C303.1, D302.2 (A), F101.2, R301.2, R302.2, U101.13 (VCC), U301.2 (CE), U301.7 (VIN), USB103.1 (VBUS), USB104.1 (VBUS)
/BAT: BT1.1 (+), C304.2, C305.2, D301.1 (K), D303.2 (A), R304.2, U301.3 (BAT)
/BGND: C301.1, C302.1, C303.2, C304.1, C305.1, Q301.2 (S), Q302.6 (S2), Q302.7 (S2), Q303.1 (D), R306.2, U301.4 (GND)
/BT-: BT2.2 (-), C306.1, C307.1, Q302.2 (S1), Q302.3 (S1), U302.6 (VSS)
/DD301: Q302.1 (D1/D2), Q302.8 (D1/D2)
/ESP_EN: C403.2, J404.5, Q202.3 (C), R401.2, SW401.2, U401.41 (EN)
/ESP_IO0: J401.1, J404.6, Q201.3 (C), R402.2, SW402.2, U401.3 (IO0)
/ESP_IO2: J401.3, R404.1, U401.5 (IO2)
/ESP_RX: J404.3, U201.2 (TXD), U401.38 (RXD0)
/ESP_SCL: J401.10, U401.12 (IO9), U402.3
/ESP_SDA: J401.9, U401.11 (IO8), U402.4
/ESP_TX: J404.2, U201.3 (RXD), U401.37 (TXD0)
/LC301: C310.2, L302.1, U303.6 (SW)
/LD301: D301.2 (A), L301.2, Q301.1 (D)
/LR301: L301.1, R302.1, U301.8 (CSN)
/USB_1_D+: U101.8 (DP1), U201.5 (UD+)
/USB_1_D-: U101.7 (DM1), U201.6 (UD-)
/USB_2_D+: J403.7, U101.6 (DP2), U401.23 (IO20)
/USB_2_D-: J403.6, U101.5 (DM2), U401.22 (IO19)
/USB_3_D+: U101.4 (DP3), USB103.3 (D+)
/USB_3_D-: U101.3 (DM3), USB103.2 (D-)
/USB_4_D+: U101.2 (DP4), USB104.3 (D+)
/USB_4_D-: U101.1 (DM4), USB104.2 (D-)
/USB_IN_D+: U101.11 (DP), USB101.3 (D+), USB102.A6 (D+), USB102.B6 (D+)
/USB_IN_D-: U101.10 (DM), USB101.2 (D-), USB102.A7 (D-), USB102.B7 (D-)
/USB_IN_RX+: USB101.9 (SSRX+), USB102.A11 (RX2+), USB103.9 (SSTX+)
/USB_IN_RX-: USB101.8 (SSRX-), USB102.A10 (RX2-), USB103.8 (SSTX-)
/USB_IN_TX+: USB101.6 (SSTX+), USB102.B2 (TX2+), USB103.6 (SSRX+)
/USB_IN_TX-: USB101.5 (SSTX-), USB102.B3 (TX2-), USB103.5 (SSRX-)
/VIN: F101.1, USB101.1 (VBUS), USB102.A4 (VBUS), USB102.A9 (VBUS), USB102.B4 (VBUS), USB102.B9 (VBUS)
GND: C101.2, C102.2, C104.2, C105.2, C201.1, C202.1, C308.1, C309.1, C311.1, C312.1, C313.2, C401.2, C402.2, C403.1, D401.1 (K), D402.1 (K), J404.4, J406.2, J406.4, J406.6, J407.2, J407.4, J407.6, Q303.2 (S), R101.2, R102.2, R309.1, SW301.3 (C), SW301.6 (C), SW401.1, SW402.1, U101.16 (GND), U201.1 (GND), U303.2 (GND), U401.1 (GND), U401.26 (GND), U401.42 (GND), U401.43 (GND), U402.1, USB101.4 (GND), USB101.7 (DRAIN), USB101.10 (SHIELD), USB102.A1 (GND), USB102.A12 (GND), USB102.B1 (GND), USB102.B12 (GND), USB102.S1 (SHIELD), USB103.4 (GND), USB103.7 (DRAIN), USB103.10 (SHIELD), USB104.4 (GND), USB104.5 (Shield)
unnamed: BT1.2 (-), BT2.1 (+), R305.2
unnamed: C104.1, C105.1, U101.12 (DCP), U101.14 (V33)
unnamed: C301.2, R301.1
unnamed: C306.2, R304.1, U302.5 (VDD)
unnamed: C307.2, R305.1, U302.4 (VC)
unnamed: C310.1, U303.1 (BST)
unnamed: C314.1, R308.1, R309.2, U303.3 (FB)
unnamed: D401.2 (A), R403.2
unnamed: D402.2 (A), R404.2
unnamed: J401.2, U401.4 (IO1)
unnamed: J401.4, U401.6 (IO3)
unnamed: J401.5, U401.7 (IO4)
unnamed: J401.6, U401.8 (IO5)
unnamed: J401.7, U401.9 (IO6)
unnamed: J401.8, U401.10 (IO7)
unnamed: J401.11, U401.13 (IO10)
unnamed: J401.12, U401.14 (IO11)
unnamed: J401.13, U401.15 (IO12)
unnamed: J401.14, U401.16 (IO13)
unnamed: J402.1, U401.40 (IO46)
unnamed: J402.2, U401.39 (IO45)
unnamed: J402.3, U401.36 (IO42)
unnamed: J402.4, U401.35 (IO41)
unnamed: J402.5, U401.34 (IO40)
unnamed: J402.6, U401.33 (IO39)
unnamed: J402.7, U401.32 (IO38)
unnamed: J402.8, U401.31 (IO37)
unnamed: J402.9, U401.30 (IO36)
unnamed: J402.10, U401.29 (IO35)
unnamed: J402.11, U401.28 (IO34)
unnamed: J402.12, U401.27 (IO33)
unnamed: J402.13, U401.25 (IO26)
unnamed: J402.14, U401.24 (IO21)
unnamed: J403.1, U401.17 (IO14)
unnamed: J403.2, U401.18 (IO15)
unnamed: J403.3, U401.19 (IO16)
unnamed: J403.4, U401.20 (IO17)
unnamed: J403.5, U401.21 (IO18)
unnamed: Q201.1 (B), R202.1
unnamed: Q201.2 (E), R201.2, U201.13 (~DTR)
unnamed: Q202.1 (B), R201.1
unnamed: Q202.2 (E), R202.2, U201.14 (~RTS)
unnamed: Q301.3 (G), R303.1
unnamed: Q302.4 (G1), U302.1 (DOUT)
unnamed: Q302.5 (G2), U302.2 (COUT)
unnamed: Q303.3 (G), SW301.2 (B), SW301.5 (B)
unnamed: R101.1, USB102.B5 (CC2)
unnamed: R102.1, U101.9 (REF)
unnamed: R303.2, U301.5 (LDRV)
unnamed: R306.1, U302.3 (VM)
unnamed: R307.1, U303.4 (EN)
unnamed: R310.1, SW301.1 (A), SW301.4 (A)
VCC: C308.2, C309.2, D302.1 (K), D303.1 (K), R307.2, R310.2, U303.5 (VIN)

Notes on the sheet:
1 不使用电池 2 使用电池供电
充电电路连接在一起再接系统地 充电电路接地时与4脚分开接地
USB转串口
供电切换电路
电池和保护电路
USB
3.3V降压电路
充电电路

Board: 2 copper layers, 100.0 x 70.0 mm, 80 parts (3 on the bottom side), 85 nets.

## Commit log

2021-12-29 更新项目
2021-12-31 更新电路图
2022-01-05 更新 .gitignore
2022-01-14 更新说明文件
2022-05-30 添加S3开发板
2022-06-02 添加丝印
2022-06-09 添加sbs3开发板介绍和图片
